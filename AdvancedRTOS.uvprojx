# Keil uVision project AdvancedRTOS.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AdvancedRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source code
    ../inc/: BSP.c Profile.c
    ./: osasm.s os.c mainFile.c Queue.c Filesystem.c eDisk.c FlashProgram.c Scheduler.c Semaphore.c Threads.c MemManage.c our_stdio.c
  group Object code
    ./: texas.o
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
